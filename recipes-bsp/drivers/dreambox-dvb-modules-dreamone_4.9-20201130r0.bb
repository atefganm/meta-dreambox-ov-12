SRC_URI[dreamone.md5sum] = "a3b979ee0278c795f90d11a9e12bc8fa"
SRC_URI[dreamone.sha256sum] = "8bb91874641b0c6200c336b9ee767c073efba73fd2dd4e5c4a17f9db9b192150"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamone)$"
