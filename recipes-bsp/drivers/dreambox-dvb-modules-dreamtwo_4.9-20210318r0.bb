SRC_URI[dreamtwo.md5sum] = "07e6a4c72aa3114aef5ade0bb572d3e9"
SRC_URI[dreamtwo.sha256sum] = "331c55dfb6a353a4aae8d2208ba8eba90eda2feec0daac6abac6e233c5b5a5d2"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamtwo)$"
