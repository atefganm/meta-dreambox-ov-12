SRC_URI[dreamone.md5sum] = "c2f0700df91700122f510c4525ed47c3"
SRC_URI[dreamone.sha256sum] = "cfe114c44133ea0ba507e88157abf4e5e4bc3f2a683427c7b050b6c421ebeae7"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamone)$"
