SRC_URI[dreamtwo.md5sum] = "c1c7dd25b8cdca4cf1a8348cb8b3fcf3"
SRC_URI[dreamtwo.sha256sum] = "aeb97a03a8148c6fe9aef87bdc05d5f340b13b290ff7f91d673e26d705f5aac8"

require dreambox-dvb-modules-meson.inc

COMPATIBLE_MACHINE = "^(dreamtwo)$"
