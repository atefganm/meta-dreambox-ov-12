require dreambox-stb-kodi.inc

COMPATIBLE_MACHINE = "^(dm920)$"
