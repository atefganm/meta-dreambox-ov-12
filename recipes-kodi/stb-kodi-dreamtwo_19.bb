require dmamlogic-stb-kodi.inc

COMPATIBLE_MACHINE = "^(dreamtwo)$"
